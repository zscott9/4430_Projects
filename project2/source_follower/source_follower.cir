* Source Follower Sim
.include C:\Users\ber20\Google Drive\BS.ECE\2023-2024\ECE 4430\Project2\models.sp
X1 vdd vin vout gnd sky130_fd_pr__nfet_01v8 ad=0.68 pd=3.4 as=0.26 ps=1.5 w=0.8 l=0.4
X2 vout vtau gnd gnd sky130_fd_pr__nfet_01v8 ad=0.26 pd=1.5 as=0.48 ps=2.9 w=0.8 l=0.4
* Remove set ac source to zero for DC analysis
v1 vin vdc ac=1
v2 vdc gnd 1.3
v3 vtau gnd 0.45
v4 vdd gnd 1.8
c1 vout gnd 100e-15
*.dc v2 0 1.8 0.05
.ac dec 100 1 1e9
