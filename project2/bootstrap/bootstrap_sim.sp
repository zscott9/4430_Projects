*stuff
.include C:\Users\ber20\Google Drive\BS.ECE\2023-2024\ECE 4430\Project2\models.sp
X1 RESIST vdd gnd PBIAS nbias sky130_hilas_Bootstrap01
v1 vdd gnd 1.8
v2 RESIST gnd 0
.dc v1 1.7 1.9 0.05
