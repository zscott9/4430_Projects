* Test
.include C:\Users\ber20\hilas_shared\4430_Projects\project3\models.sp
X1 gnd vin1 vdd vdd sky130_fd_pr__pfet_01v8 w=18 l=1.0
V1 vdd gnd 0.3
V2 vin1 gnd 0.3
.dc v1 0.6 1.8 0.05
