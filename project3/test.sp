* Test
.include C:\Users\ber20\hilas_shared\4430_Projects\project3\models.sp
X1 vdd vin1 gnd gnd sky130_fd_pr__nfet_01v8 w=18 l=1.0
V1 vdd gnd 1.8
V2 vin1 gnd 0.6
.dc v2 0 1.8 0.05
